# Keil uVision project boot.uvproj, settings and files
target boot (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: boot +hex
  AfterMake: fromelf.exe  --bin -o  ..\OBJ\boot.bin ..\OBJ\boot.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\IAP;..\HARDWARE\myflash;..\Comm\communication3;..\Comm\usart3;..\APP\crc;..\LowDrivers\mySpi;..\HighDrivers\sst25vf016;..\APP\prog;..\APP\iap;..\HighDrivers\LCD12864
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c common.c
  group LowDrivers
    ../LowDrivers/mySpi/: mySpi.c mySpi.h
  group HighDrivers
    ../HighDrivers/sst25vf016/: sst25VF016.c sst25VF016.h
    ../HighDrivers/LCD12864/: lcd12864.c lcd12864.h
  group APP
    ../APP/crc/: CRC.c CRC.h
    ../APP/iap/: iap.c iap.h
    ../APP/prog/: prog.c prog.h
  group COMM
    ../Comm/usart3/: usart3.c usart3.h
    ../Comm/communication3/: communication3.c communication3.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/myflash/: myflash.c
  group IAP
    ../IAP/: download.c upload.c ymodem.c
