# Keil uVision project UCOSII-2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UCOSII-2 +hex
  AfterMake: fromelf.exe  --bin -o  ..\OBJ\UCOSII-2.bin ..\OBJ\UCOSII-2.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HighDrivers\BEEP;..\HighDrivers\wt588d16;..\AppCodes\App;..\AppCodes\Task;..\LowDrivers\mySpi;..\HighDrivers\sst25vf016;..\HighDrivers\LCD12864;..\HighDrivers\speaker;..\Comm\usart3;..\Comm\communication3;..\AppCodes\common;..\AppCodes\crc;..\AppCodes\prog;..\AppCodes\ziku;..\HighDrivers\myFlash;..\HighDrivers\rtc;..\HighDrivers\oled;..\LowDrivers\stm32spi1;..\HighDrivers\bikeRC522;..\AppCodes\bikeCard;..\LowDrivers\stm32spi2;..\HighDrivers\userRC522;..\AppCodes\userCard;..\Comm\can1;..\Comm\can1Comm;..\HighDrivers\myTimer;..\HighDrivers\led;..\LowDrivers\myiic;..\HighDrivers\pcf8563;..\AppCodes\softTimer;..\HighDrivers\lock
  memory RVCT4: ROM 0x8010000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group LowDrivers
    ../LowDrivers/mySpi/: mySpi.c myspi.h
    ../LowDrivers/stm32spi1/: stm32spi1.c stm32spi1.h
    ../LowDrivers/stm32spi2/: stm32spi2.c stm32spi2.h
    ../LowDrivers/myiic/: myiic.c myiic.h
  group HighDrivers
    ../HighDrivers/led/: led.c led.h
    ../HighDrivers/BEEP/: beep.c beep.h
    ../HighDrivers/lock/: lock.c lock.h
    ../HighDrivers/speaker/: speaker.c speaker.h
    ../HighDrivers/wt588d16/: wt588d16.c wt588d16.h
    ../HighDrivers/sst25vf016/: sst25VF016.c sst25VF016.h
    ../HighDrivers/LCD12864/: lcd12864.c lcd12864.h
    ../HighDrivers/myFlash/: myflash.c myflash.h
    ../HighDrivers/rtc/: rtc.c rtc.h
    ../HighDrivers/oled/: oled.c oled.h
    ../HighDrivers/bikeRC522/: bikeRC522.c bikeRC522.h
    ../HighDrivers/userRC522/: userRC522.c userRC522.h
    ../HighDrivers/myTimer/: mytimer.c mytimer.h
    ../HighDrivers/pcf8563/: pcf8563.c pcf8563.h
  group APPCode
    ../AppCodes/App/: App.c App.h
    ../AppCodes/Task/: Task.c Task.h
    ../AppCodes/common/: common.c common.h
    ../AppCodes/crc/: CRC.c CRC.h
    ../AppCodes/prog/: prog.c prog.h
    ../AppCodes/ziku/: ziku.c ziku.h
    ../AppCodes/bikeCard/: bikeCard.c bikeCard.h
    ../AppCodes/userCard/: userCard.c userCard.h
    ../AppCodes/softTimer/: softTimer.c softTimer.h
  group Comm
    ../Comm/communication3/: communication3.c communication3.h
    ../Comm/usart3/: usart3.c usart3.h
    ../Comm/can1Comm/: can1Comm.c can1Comm.h
    ../Comm/can1/: can1.c can1.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/sys/: sys.c sys.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_wwdg.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
